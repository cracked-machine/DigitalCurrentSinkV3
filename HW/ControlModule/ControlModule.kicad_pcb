# Repository cracked-machine/DigitalCurrentSinkV3 (continued)

## KiCad design HW/CurrentSinkModule/CurrentSinkModule/CurrentSinkModule.kicad_pcb (continued)

Parts:
C1, C2, C3, C4: C; C_0402_1005Metric
C5, C6, C9, C10, C27, C28, C31, C32: 4.7u; C_0402_1005Metric
C7, C8, C11, C12, C23, C24, C25, C26, C29, C30, C33, C34: 10n; C_0402_1005Metric
C13, C14, C15, C16: 1n 5% Mica/C0G; C_0402_1005Metric
C17, C18: 22n; C_0402_1005Metric
C19, C20, C21, C22: 330n; C_0402_1005Metric
D3, D4: 3V3; D_SOD-123
GND1, GND2, GND3, GND4, GND5, GND6, GND7, GND8, GND10, GND11: TestPoint; TestPoint_Pad_2.0x2.0mm; MouserNo 855-S2751-46R
HS1: Power Resistor Heatsink; LAM_5_100_12; MouserNo 774-2811
J1, J2: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J3, J4: MosfetSocketx3; TerminalBlock_bornier-3_P5.08mm
J_RHIGH1, J_RHIGH2: Wurth 74650195R; Wurth_74651173
J_RLOW1, J_RLOW2: Wurth 74650195R; Wurth_74651173
R1, R2, R3, R4, R5, R6, R7, R8, R17, R18, R19, R20, R22, R25, R26: R; R_0402_1005Metric
R9, R10, R11, R12: 22K 1%; R_0402_1005Metric
R13, R16: 100R; R_0402_1005Metric
R14, R15, R23: 0R; R_0402_1005Metric
R21, R24: R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R27, R28: 10K; R_0402_1005Metric
TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14: TestPoint; TestPoint_Pad_2.0x2.0mm; MouserNo 855-S2751-46R
U1, U2, U3, U4: LTC2058; SOIC-8_3.9x4.9mm_P1.27mm; MouserNo 584-ADA4522-2ARMZ
U_NEGIA1: INA128UA; SOIC-8_3.9x4.9mm_P1.27mm; MouserNo 595-INA128UA/2K5
U_POSIA1: INA128UA; SOIC-8_3.9x4.9mm_P1.27mm; MouserNo 595-INA128UA/2K5

Connections:
+12V: C5.1, C7.1, C9.1, C11.1, C19.2, C21.2, C23.1, C25.1, C27.1, C29.1, C31.1, C33.1, U1.8 (V+), U2.8 (V+), U3.8 (V+), U4.8 (V+), U_NEGIA1.7 (Vs+), U_POSIA1.7 (Vs+); also elsewhere on the board
-12V: C6.1, C8.1, C10.1, C12.1, C20.2, C22.2, C24.1, C26.1, C28.1, C30.1, C32.1, C34.1, U1.4 (V-), U2.4 (V-), U3.4 (V-), U4.4 (V-), U_NEGIA1.4 (Vs-), U_POSIA1.4 (Vs-); also elsewhere on the board
/CurrentSink/ADCSIG1: D3.1 (K), R23.1, TP13.1, U3.7; also elsewhere on the board
/CurrentSink/ADCSIG2: D4.1 (K), R16.2, TP14.1, U4.7; also elsewhere on the board
/CurrentSink/DACSIG1: R2.2, R27.2, TP4.1; also elsewhere on the board
/CurrentSink/DACSIG2: R1.2, R28.2, TP3.1; also elsewhere on the board
/CurrentSink/DUT_NEG: J4.2; also elsewhere on the board
/CurrentSink/DUT_POS: J3.2; also elsewhere on the board
GNDS: C1.2, C2.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C19.1, C20.1, C21.1, C22.1, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, D3.2 (A), D4.2 (A), GND1.1, GND2.1, GND3.1, GND4.1, GND5.1, GND6.1, GND7.1, GND8.1, GND10.1, GND11.1, J_RLOW1.1, J_RLOW2.1, R5.1, R9.2, R11.2, R15.1, R22.2, R26.1, R27.1, R28.1, U_NEGIA1.5 (Ref), U_POSIA1.5 (Ref); also elsewhere on the board
unnamed: C1.1, R17.1
unnamed: C2.1, R18.1
unnamed 11: C3.1, R7.1, R19.1, U1.1; also elsewhere on the board
unnamed: C3.2, R1.1, R3.2
unnamed 13: C4.1, R20.1, R25.1, U2.1; also elsewhere on the board
unnamed: C4.2, R2.1, R4.2
unnamed: C13.1, C17.2, R10.2, TP8.1, U_POSIA1.3 (+)
unnamed: C14.1, C18.2, R12.2, TP10.1, U_NEGIA1.3 (+)
unnamed: C15.1, C17.1, R9.1, TP7.1, U_POSIA1.2 (-)
unnamed: C16.1, C18.1, R11.1, TP9.1, U_NEGIA1.2 (-)
unnamed 21: J1.1, R8.2, U1.7; also elsewhere on the board
unnamed: J1.2, U4.3 (+)
unnamed 23: J2.1, R6.1, U2.7; also elsewhere on the board
unnamed: J2.2, U3.3 (+)
unnamed: J3.1, TP6.1, U3.1
unnamed: J3.3, J_RHIGH1.1, R10.1, R24.1
unnamed: J4.1, TP5.1, U4.1
unnamed: J4.3, J_RHIGH2.1, R12.1, R21.1
unnamed 33: R3.1, R17.2, U1.3 (+); also elsewhere on the board
unnamed 34: R4.1, R18.2, U2.3 (+); also elsewhere on the board
unnamed 35: R7.2, R8.1, U1.6 (-); also elsewhere on the board
unnamed 36: R6.2, U2.6 (-); also elsewhere on the board
unnamed 37: R13.2, TP12.1, U_NEGIA1.6; also elsewhere on the board
unnamed 38: R14.2, TP11.1, U_POSIA1.6; also elsewhere on the board
unnamed: R5.2, U1.5 (+)
unnamed: R13.1, R16.1, U4.6 (-)
unnamed: R14.1, R15.2, U3.5 (+)
unnamed: R19.2, U1.2 (-)
unnamed: R20.2, U2.2 (-)
unnamed: R21.2, U4.2 (-)
unnamed: R22.1, U4.5 (+)
unnamed: R23.2, U3.6 (-)
unnamed: R24.2, U3.2 (-)
unnamed: R25.2, R26.2, U2.5 (+)

Notes on the sheet:
To help dissipate power resistors and MOSFETS
ANALOG POWER
DAC INPUT
SENSE FEEDBACK
DUT INPUT
N-Channel Power Mosfet IXFK50N85X https://www.littelfuse.com/~/media/electronics/datasheets/discrete_mosfets/littelfuse_discrete_mosfets_n-channel_ultra_junction_ixf_50n85x_datasheet.pdf.pdf
Power Resistor Arcol HS100 1ohm 100W
P-Channel Power Mosfet IXTK90P20P https://m.littelfuse.com/~/media/electronics/datasheets/discrete_mosfets/littelfuse_discrete_mosfets_p-channel_ixt_90p20p_datasheet.pdf.pdf
InstGain: 14dB
Non-Inverting Atten. OutputGain: -11.4dB
Input Isolation Disconnect load first!
Constant Voltage
INPUT BIAS COMPENSATION
INPUT BIAS COMPENSATION. IF NOT USED MUST BE POPULATED WITH 0R RESISTOR
Max 3.3V
Max 12V
To bypass active filter populate: R2, R4 and R20 with 0R resistors, omit others
To bypass active filter populate: R1, R3 and R19 with 0R resistors, omit others
To bypass inverting gain amp populate: R7 and R8 with 1K resistors, R5 with 0R resistor, omit others
To bypass non-inverting gain amp populate: R25 and R6 with 0R resistors omit others
To bypass non-inverting opamp populate: R14 and R23 with 0R resistors, omit others
To bypass inverting opamp populate: R13 and R16 with 1K resistors, R22 0R, omit others
Expect increasing negative voltage on TP10 and TP12 as U4A output voltage increases. TP9 should remain at GND (some offset normal). The output is inverted by U4B so TP14 should increase inversely proportional to TP10 and TP12.
Expect increasing positive voltage on TP8 and TP11 as U3A output voltage increases. TP7 should remain at GND (some offset normal).

Board: 4 copper layers, 100.3 x 100.3 mm, 121 parts (28 on the bottom side), 49 nets.

Other parts of the board:
JP5, JP6, JP7, JP8, JP9, JP10: BYPASS; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm

Their connections:
/CurrentSink/ADCSIG1: JP10.2; also elsewhere on the board
/CurrentSink/ADCSIG2: JP9.2; also elsewhere on the board
unnamed 11: JP5.2; also elsewhere on the board
unnamed 13: JP6.2; also elsewhere on the board
unnamed 21: JP7.2; also elsewhere on the board
unnamed 23: JP8.2; also elsewhere on the board
unnamed 33: JP5.1; also elsewhere on the board
unnamed 34: JP6.1; also elsewhere on the board
unnamed 35: JP7.1; also elsewhere on the board
unnamed 36: JP8.1; also elsewhere on the board
unnamed 37: JP9.1; also elsewhere on the board
unnamed 38: JP10.1; also elsewhere on the board

## KiCad design HW/IsolatedThreeOutputSMPS/ExternRegulatedConverters/24VIN_ExternRegulatedConverter_12D_24S_5S/24VIN_ExternRegulatedConverter_12D_24S_5S.kicad_pcb

Parts:
C1: 4.7uF; CP_Elec_4x5.7
C2, C5: 330nF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C3: 33p; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C4: 220p; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C6: 220nF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C7, C8, C10: 100nF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D1: BZT52C5V1; D_SMA_Handsoldering
D3, D4, D5, D6, D7: LED; LED_D3.0mm
J1: 24VDC; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J2: Conn_01x07; Molex_KK-254_AE-6410-07A_1x07_P2.54mm_Vertical
Q1: IPP80P03P4L04AKSA1; TO-220-3_Vertical
R1: 100K; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R3: 10K; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R4: 6K8; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R5, R6: 4K7; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R7: 1K2; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
U1: L78L12_TO92; TO-92_Inline_Wide
U2: L79L12_TO92; TO-92_Inline_Wide
U4: R2D-2415; R2D
U5: LM7805_TO220; TO-220-3_Vertical

Connections:
+5V: C10.1, J2.6, R7.1, U5.3 (VO)
+12V: C7.1, J2.1, R5.1, U1.1 (VO)
+24V: C1.1, C3.2, C6.1, D1.1 (K), J2.4, Q1.3 (S), R3.1, R4.1, U4.2 (+Vin), U5.1 (VI)
-12V: C8.2, J2.3, R6.1, U2.3 (VO)
/+15VA: C2.1, C3.1, U1.3 (VI), U4.7 (+Vout)
/-15VA: C4.1, C5.2, U2.2 (VI), U4.5 (-Vout)
GNDS: C1.2, C4.2, C6.2, C10.2, D3.1 (K), D4.1 (K), D7.1 (K), J1.1, J2.5, J2.7, R1.2, U4.1 (-Vin), U5.2 (GND)
unnamed: D1.2 (A), Q1.1 (G), R1.1
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: D6.1 (K), R6.2
unnamed: D7.2 (A), R7.2
unnamed: J1.2, Q1.2 (D)
VCOM: C2.2, C5.1, C7.2, C8.1, D5.1 (K), D6.2 (A), J2.2, U1.2 (GND), U2.1 (GND), U4.4 (COM)

Notes on the sheet:
Pin Assignments: ——————————— 1. Analog +12V 2. Isolated GND 3. Analog -12V 4. Fan +24V 5. Common GND 6. Digital +5V 7. Common GND PSU Module Nominal Current Usage: 65mA PSU Current Requirements: —————————————————— A) Analog +/-12V —> CurrentSinkModule: 30mA B) Digital +5V —> ControlModule: 100mA C)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
Input/Output Connectors
B) Microcontroller PSU
A) Analog PSU
Unregulated
