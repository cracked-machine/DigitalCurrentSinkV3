# Repository cracked-machine/DigitalCurrentSinkV3 (continued)

## KiCad design HW/IsolatedThreeOutputSMPS/ExternRegulatedConverters/24VIN_ExternRegulatedConverter_12D_24S_5S/24VIN_ExternRegulatedConverter_12D_24S_5S.kicad_pcb (continued)

Board: 2 copper layers, 69.8 x 44.5 mm, 28 parts (11 on the bottom side), 15 nets.

## KiCad design HW/IsolatedThreeOutputSMPS/ExternRegulatedConverters/24VIN_ExternRegulatedConverter_12D_12S_5S/24VIN_ExternRegulatedConverter.kicad_pcb

Parts:
C1, C14: 4.7uF; CP_Elec_4x5.7
C2, C6, C7, C9: 330nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3: 33p; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C4: 220p; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C5: 100nF; CP_Elec_4x5.7
C8: 2.2uF; CP_Elec_4x5.7
C10, C11: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C12, C13: 1uF; CP_Elec_4x5.7
D1: BYS12-90-E3/TR; D_SMA_Handsoldering
D2: ES2G; D_SMA_Handsoldering
D3, D4, D5, D6, D7: LED; LED_D3.0mm
HS1: SK 480/50 SA; SK512_SK480_50MM
HS2, HS3: SK 481/50 SA; SK481_SK480_25MM
J1: 24VDC; PinHeader_1x02_P2.54mm_Horizontal
J2: Conn_01x07; Molex_KK-254_AE-6410-07A_1x07_P2.54mm_Vertical
L1: 1mH; L_Neosid_SM-NE127_HandSoldering
R3: 10K; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R4: 6K8; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R5, R6: 4K7; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R7: 1K2; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
U1: ISE2409A-H; ISE
U2: LM7812_TO220; TO-220-3_Vertical
U3: LM7912_TO220; TO-220-3_Vertical
U4: R2D-2415; R2D
U5: LM7805_TO220; TO-220-3_Vertical
U6: L7818CV; TO-220-3_Vertical
U7: L78M15ABV; TO-220-3_Vertical

Connections:
+5V: C10.1, J2.6, R7.1, U5.3 (VO)
+12V: C11.1, J2.1, R5.1, U2.3 (VO)
+15V: C13.1, D2.1 (K), J2.4, R4.1, U7.3 (VO)
+24V: C1.1, C2.1, C3.2, C14.1, D1.1 (K), L1.1, R3.1, U4.2 (+Vin), U6.1 (VI)
-12V: C12.2, J2.3, R6.1, U3.3 (VO)
/+9V: C6.1, U1.5 (+Vout), U5.1 (VI)
/+15VA: C3.1, C7.1, U2.1 (VI), U4.7 (+Vout)
/+18V: C5.1, C9.1, U6.3 (VO), U7.1 (VI)
/-15VA: C4.1, C8.2, U3.2 (VI), U4.5 (-Vout)
GNDS: C1.2, C2.2, C4.2, C5.2, C6.2, C9.2, C10.2, C13.2, C14.2, D2.2 (A), D3.1 (K), D4.1 (K), D7.1 (K), J1.1, J2.5, J2.7, U1.1 (-Vin), U1.4 (0V), U4.1 (-Vin), U5.2 (GND), U6.2 (GND), U7.2 (GND)
unnamed: D1.2 (A), J1.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: D6.1 (K), R6.2
unnamed: D7.2 (A), R7.2
unnamed: L1.2, U1.2 (+Vin)
VCOM: C7.2, C8.1, C11.2, C12.1, D5.1 (K), D6.2 (A), J2.2, U2.2 (GND), U3.1 (GND), U4.4 (COM)

Notes on the sheet:
Pin Assignments: ——————————— 1. Analog +12V 2. Isolated GND 3. Analog -12V 4. Fan +15V 5. Common GND 6. Digital +5V 7. Common GND PSU Module Nominal Current Usage: 65mA PSU Current Requirements: —————————————————— A) Analog +/-12V —> CurrentSinkModule: 30mA B) Digital +5V —> ControlModule: 100mA C)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
Input/Output Connectors
B) Microcontroller PSU
A) Analog PSU
C) Fan PSU
Unregulated
Thermal Spec: —————————— Amb: 30C 7818: 5K/W 7815: 3K/W SK481: 5.5K/W
Inductive Load Protection
Shared Between Analog/MCU regulators
U6 JC Power Dissipation: (24V-18V) * 0.7A = 4.2W U6 JC Temp: 5 * 4.2 = 21 degC HS2 Temp = 4.2 * 5.5 = 23.1 degC Total U6 Temp = 30 + 21C + 23.1 = 74 degC
U7 JC Power Dissipation: (18V-15V) * 0.7A = 2.1W U7 JC Temp: 3 * 2.1 = 6.3 degC HS3 Temp = 2.1 * 5.5 = 11.5 degC Total U7 Temp = 30 + 6.3C + 11.5 = 47.8 degC

Board: 2 copper layers, 85.1 x 50.8 mm, 39 parts (15 on the bottom side), 18 nets.

## KiCad design HW/IsolatedThreeOutputSMPS/ExternRegulatedConverters/ExternRegulatedConverter_12D_12S_5S_DelayedStart/ExternRegulatedConverter_12D_12S_5S_DelayedStart.kicad_pcb

Board: 2 copper layers, 71.1 x 47.0 mm, 20 parts (8 on the bottom side), 10 nets.

Parts:
C1: 2.2uF; CP_Elec_4x5.7
C2, C5, C7: 330nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3: 33p; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C4: 220p; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C6, C9, C10: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C8, C11: 10uF; CP_Elec_4x5.7
D1: D_Schottky; D_SMA_Handsoldering
HS1: Heatsink; Heatsink_SheetType_50x7mm_2Fixations
J1: 15VDC; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J2: Conn_01x07; Molex_KK-254_AE-6410-07A_1x07_P2.54mm_Vertical
U1: RS6-1212D; ITX1212S
U2: LM7805_TO220; TO-220-3_Vertical
U3, U5: LM7812_TO220; TO-220-3_Vertical
U4: LM7912_TO220; TO-220-3_Vertical

Connections:
+5V: C9.1, J2.4, U2.3
+12P: C6.1, J2.6, U5.3
+12V: C10.1, J2.1, U3.3
+15V: C1.1, C2.1, C3.2, C5.1, D1.1, U1.2, U2.1, U5.1
-12V: C11.2, J2.3, U4.3
GNDA: C1.2, C2.2, C4.2, C5.2, C6.2, C9.2, J1.1, J2.5, J2.7, U1.1, U2.2, U5.2
unnamed: C3.1, C7.1, U1.6, U3.1
unnamed: C4.1, C8.2, U1.8, U4.2
unnamed: D1.2, J1.2
VCOM: C7.2, C8.1, C10.2, C11.1, J2.2, U1.7, U3.2, U4.1

## KiCad design HW/IsolatedThreeOutputSMPS/ExternRegulatedConverters/ExternRegulatedConverter_5D_12S_5S/ExternRegulatedConverter.kicad_pcb

Parts:
C1: 47p; C_Disc_D4.3mm_W1.9mm_P5.00mm
C2, C5: 200nF; C_Rect_L7.0mm_W2.0mm_P5.00mm
C3: 47p; C_Disc_D3.0mm_W2.0mm_P2.50mm
C6, C9: 100nF; C_Rect_L7.0mm_W2.0mm_P5.00mm
C10, C11: 4.7u; CP_Radial_D5.0mm_P2.50mm
D1: D_Schottky; D_DO-41_SOD81_P10.16mm_Horizontal
HS1: Heatsink; Heatsink_SheetType_50x7mm_2Fixations
J1: 15VDC; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J_FANPWR1: Conn_01x02; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J_MCUPWR1: Conn_01x02; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J_OAPWR1, J_OAPWR2: Conn_01x03; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
L1, L2: 10u; L_Radial_D6.0mm_P4.00mm
U1: MEA1D1505DC; MEA1D
U2: LM7805_TO220; TO-220-3_Vertical
U5: LM7812_TO220; TO-220-3_Vertical

Connections:
+5V: C9.1, J_MCUPWR1.1, U2.3 (VO)
+5VA: C10.1, J_OAPWR1.1, J_OAPWR2.1, L1.2
+12V: C6.1, J_FANPWR1.1, U5.3 (VO)
+15V: C1.2, C2.1, C5.1, D1.1 (K), U1.14 (Vin+), U2.1 (VI), U5.1 (VI)
-5VA: C11.2, J_OAPWR1.3, J_OAPWR2.3, L2.2
GNDA: C2.2, C3.2, C5.2, C6.2, C9.2, J1.1, J_FANPWR1.2, J_MCUPWR1.2, U1.1 (Vin-), U2.2 (GND), U5.2 (GND)
unnamed: C1.1, L1.1, U1.9 (Vout+)
unnamed: C3.1, L2.1, U1.11 (Vout-)
unnamed: D1.2 (A), J1.2
VCOM: C10.2, C11.1, J_OAPWR1.2, J_OAPWR2.2, U1.8 (GND)

Board: 2 copper layers, 71.1 x 49.5 mm, 20 parts (0 on the bottom side), 10 nets.

## KiCad design HW/IsolatedThreeOutputSMPS/VariableExternRegulatedConverters/ExternRegulatedConverter/VariableExternRegulatedConverter.kicad_pcb

Board: 2 copper layers, 81.3 x 68.6 mm, 26 parts (0 on the bottom side), 15 nets.

Parts:
C1, C7, C8: 10uF; CP_Radial_D5.0mm_P2.50mm
C2: 200nF; C_Rect_L7.0mm_W2.0mm_P5.00mm
C3: 47p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C4: 100p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C5, C6, C9: 100nF; C_Rect_L7.0mm_W2.0mm_P5.00mm
C10, C11: 1uF; CP_Radial_D5.0mm_P2.50mm
D1: D_Schottky; D_DO-41_SOD81_P7.62mm_Horizontal
HS1: Heatsink; Heatsink_SheetType_50x7mm_2Fixations
J1: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J2: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
L1: 10mH; Choke_Schaffner_RN204-04-9.0x14.0mm
R1, R4: 100R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2, R3: 1K5; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1, RV2: 1K; Potentiometer_Bourns_3296Y_Vertical
U1: RS6-1212D; ITX1212S
U2: LM7805_TO220; TO-220-3_Vertical
U3: LM317_3PinPackage; TO-220-3_Vertical
U4: LM337_TO220; TO-220-3_Vertical

Connections:
+5V: C9.1, J2.4, U2.3
+12V: C10.1, J2.1, RV1.3, U3.2
-12V: C11.2, J2.3, RV2.1, U4.3
GNDA: C1.2, C2.2, C9.2, J1.1, J2.5, L1.3, U2.2
unnamed: C3.1, C5.1, U1.6, U3.3
unnamed: C3.2, L1.2, U1.2
unnamed: C4.1, C6.2, U1.8, U4.2
unnamed: C4.2, L1.4, U1.1
unnamed: C7.1, R1.2, R2.1, U3.1
unnamed: C8.2, R3.2, R4.1, U4.1
unnamed: D1.2, J1.2
unnamed: R1.1, RV1.1, RV1.2
unnamed: R4.2, RV2.2, RV2.3
VCOM: C5.2, C6.1, C7.2, C8.1, C10.2, C11.1, J2.2, R2.2, R3.1, U1.7
VDD: C1.1, C2.1, D1.1, L1.1, U2.1

## KiCad design HW/IsolatedThreeOutputSMPS/OutputFilteredConverters/IsolatedConverterTripleOutputPSU.kicad_pcb

Board: 2 copper layers, 78.7 x 66.0 mm, 21 parts (2 on the bottom side), 14 nets.

Parts:
C1, C2, C3, C4: 10uF; CP_Radial_D5.0mm_P2.50mm
C5, C6, C7: 220uF; CP_Radial_D8.0mm_P5.00mm
C8: 47p; C_Disc_D5.0mm_W2.5mm_P5.00mm
C9: 100p; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1: D_Schottky; D_DO-15_P2.54mm_Vertical_AnodeUp
J1: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J2: Conn_01x08; PinSocket_1x08_P2.54mm_Vertical
L1: 1mH; Choke_Schaffner_RN212-04-12.5x18.0mm
L2: 1mH; L_Radial_D12.0mm_P5.00mm_Fastron_11P
L3: 200uH; L_Radial_D8.7mm_P5.00mm_Fastron_07HCP
L4: 100uH; L_Radial_D8.7mm_P5.00mm_Fastron_07HCP
L5, L6, L7: 10uH; L_Radial_D8.7mm_P5.00mm_Fastron_07HCP
U1: RS6-1212D; ITX1212S
U2: RS6-1205S; ITX1212S

Connections:
/+5V: C7.1, J2.8, L7.2
/+12V: C5.1, J2.1, L5.2
/-12V: C6.2, J2.3, L6.2
/COM: C5.2, C6.1, J2.2, U1.7
GNDS: C1.2, C2.2, C3.2, C4.2, C7.2, C9.2, J1.1, J2.7, L1.3, L1.4, U1.1, U2.1, U2.7
unnamed: C1.1, C3.1, D1.1, L1.1, L2.1
unnamed: C2.1, L1.2, L3.1
unnamed: C4.1, L2.2, L4.1
unnamed: C8.1, L5.1, U1.6
unnamed: C8.2, L3.2, U1.2
unnamed: C9.1, L6.1, U1.8
unnamed: D1.2, J1.2
unnamed: L4.2, U2.2
unnamed: L7.1, U2.6
