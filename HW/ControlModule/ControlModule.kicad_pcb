# Repository cracked-machine/DigitalCurrentSinkV3

File README.md:

# Digital Current Sink Ver3

[Control Module Interactive BOM](https://cracked-machine.github.io/DigitalCurrentSinkV3/HW/ControlModule/doc/IBOM/ibom.html)

[Current Sink Module Interactive BOM](https://cracked-machine.github.io/DigitalCurrentSinkV3/HW/CurrentSinkModule/CurrentSinkModule/docs/IBOM/ibom.html)

[SMPS Module Interactive BOM](https://cracked-machine.github.io/DigitalCurrentSinkV3/HW/IsolatedThreeOutputSMPS/ExternRegulatedConverters/ExternRegulatedConverter_12D_12S_5S/docs/IBOM/ibom.html)

## KiCad design HW/ControlModule/ControlModule.kicad_pcb

Parts:
D1: D_Schottky; D_SMA_Handsoldering; DigikeyNo SS110FL-TPMSTR-ND
JADC1, JADC2: SMA_RG402_Coax; SMA_Amphenol_901-144_Vertical; MouserNo 571-5-1814832-1
JDAC3, JDAC4: SMA_RG402_Coax; SMA_Amphenol_901-144_Vertical; MouserNo 571-5-1814832-1
JP1, JP2, JP3, JP4: ISOLATE; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
JPWR1: KK254_01x02; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J_5VUSB1: USB_B_Micro; USB_Micro-B_Amphenol_10103594-0001LF_Horizontal; DigikeyNo 609-4050-2-ND
TP12: TestPoint; TestPoint_Pad_2.0x2.0mm; MouserNo 855-S2751-46R

Connections:
+5VD: D1.1 (K); also elsewhere on the board
/5V: D1.2 (A), JPWR1.2, J_5VUSB1.1 (VBUS), TP12.1
/Control/ADCSIG1: JADC1.1 (In); also elsewhere on the board
/Control/ADCSIG2: JADC2.1 (In); also elsewhere on the board
/Control/DACOUT1: JDAC3.1 (In); also elsewhere on the board
/Control/DACOUT2: JDAC4.1 (In); also elsewhere on the board
GNDS: JP1.2, JP2.2, JP3.1, JP4.1, JPWR1.1, J_5VUSB1.5 (GND), J_5VUSB1.6 (Shield); also elsewhere on the board
unnamed: JADC1.2 (Ext), JP1.1
unnamed: JADC2.2 (Ext), JP2.1
unnamed: JDAC3.2 (Ext), JP3.2
unnamed: JDAC4.2 (Ext), JP4.2

Parts:
C1, C2: 100nF; C_0402_1005Metric
C3, C4, C26: 0F; C_0402_1005Metric
C5, C6, C10, C12, C13, C14, C15, C16: 100n; C_0402_1005Metric
C7: 100u; CP_Elec_5x3.9
C8: 4.7uF; C_0402_1005Metric
C9: 10u; CP_Elec_5x3.9
C11: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C17: 4.7u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C18, C22: 1u X5R; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C19: 10n; C_0402_1005Metric
C20, C28, C29, C30: 1uF; C_0402_1005Metric
C21: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C23: 1u; C_0402_1005Metric
C24, C25: 0pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C27: oF; C_0402_1005Metric
J1, J2, J3, J4, J5, J6, J7, J8: Conn_01x03; MouserNo 200-CES10301TS
JOLED1: Conn_01x05; DIYMORE_SSD1309
JP5, JP6: BYPASS; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
J_KEYPAD1: Samtec ESW elevated PCB socket; PinSocket_1x07_P2.54mm_Vertical; MouserNo 200-ESW10812TS
J_SWJ_DB1: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
L1, L2: Ferrite; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R1, R2, R8, R9: 0R; R_0402_1005Metric
R3, R4: 100R; R_0402_1005Metric
R5: 10K; R_0402_1005Metric
R6, R7: 0R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R10, R11, R12, R13: 220R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
TP1, TP2, TP10, TP11, TP18, TP19: TestPoint; TestPoint_Pad_2.0x2.0mm; MouserNo 855-S2751-46R
TP20, TP21, TP22, TP23, TP24, TP25: TestPoint; TestPoint_Pad_2.0x2.0mm
TPG1, TPG2, TPG3, TPG4, TPG5, TPG6, TPG7, TPG8, TPG9, TPG10: TestPoint; TestPoint_Pad_2.0x2.0mm; MouserNo 855-S2751-46R
U1: AD8629; SOIC-8_3.9x4.9mm_P1.27mm; MouserNo 584-AD8629ARZ-R7
U2: STM32L496VGTx; LQFP-100_14x14mm_P0.5mm
U3: LM4132AMF-3.3; SOT-23-5_HandSoldering; DigikeyNo LM4132AMF-3.3/NOPBCT-ND
U4: TLV70233DBVR; SOT-23-5; MouserNo 595-TLV70233DBVR
U_BTN1: Tactile_Switch_SPST-NO; 12x12x7_3mmTactilePushButtonMomentary; MouserNo 653-B3F-5050
U_BTN2, U_BTN3, U_BTN5: Tactile_Switch_SPST-NO; 12x12x7_3mmTactilePushButtonMomentary

Connections:
+3.3VA: C5.1, C16.1, C19.1, C20.1, C23.1, C28.1, C29.1, C30.1, L1.2, U1.8 (V+), U2.21 (VREF+), U2.22 (VDDA)
+3V3: C8.1, C10.1, C12.1, C13.1, C14.1, C15.1, J_SWJ_DB1.1, L2.2, R10.1, R11.1, R12.1, R13.1, U2.11 (VDD), U2.28 (VDD), U2.50 (VDD), U2.73 (VDDUSB), U2.75 (VDD), U2.100 (VDD); also elsewhere on the board
+5VD: C7.1, C9.1, C11.1, C17.2, C18.2, JOLED1.2, R6.1, R7.2, U3.3 (EN), U3.4 (VIN), U4.1 (VIN), U4.3 (EN); also elsewhere on the board
/Control/ADCS1: C3.2, C26.2, JP5.2, R8.1, TP10.1, U1.1, U2.24 (PA1)
/Control/ADCS2: C4.1, C27.2, JP6.2, R9.1, TP11.1, U1.7, U2.25 (PA2)
/Control/ADCSIG1: R2.2, TP2.1; also elsewhere on the board
/Control/ADCSIG2: R1.2, TP1.1; also elsewhere on the board
/Control/BTN1: R11.2, U2.57 (PD10), U_BTN1.4
/Control/BTN2: R12.2, U2.58 (PD11), U_BTN3.4
/Control/BTN3: R13.2, U2.59 (PD12), U_BTN5.4
/Control/BTN4: R10.2, U2.60 (PD13), U_BTN2.4
/Control/DACOUT1: U2.29 (PA4); also elsewhere on the board
/Control/DACOUT2: U2.30 (PA5); also elsewhere on the board
/Control/KEYPAD1: J_KEYPAD1.1, U2.38 (PE7)
/Control/KEYPAD2: J_KEYPAD1.2, U2.39 (PE8)
/Control/KEYPAD3: J_KEYPAD1.3, U2.40 (PE9)
/Control/KEYPAD4: J_KEYPAD1.4, U2.41 (PE10)
/Control/KEYPAD5: J_KEYPAD1.5, U2.35 (PB0)
/Control/KEYPAD6: J_KEYPAD1.6, U2.36 (PB1)
/Control/KEYPAD7: J_KEYPAD1.7, U2.37 (PB2)
/Control/OLED_SCL: C24.2, JOLED1.3, R7.1, TP21.1, U2.92 (PB6)
/Control/OLED_SDA: C25.1, JOLED1.4, R6.2, TP20.1, U2.93 (PB7)
/Control/SWCLK: J_SWJ_DB1.2, TP22.1, U2.76 (PA14)
/Control/SWDIO: J_SWJ_DB1.4, TP23.1, U2.72 (PA13)
/Control/SWO: J_SWJ_DB1.6, TP25.1, U2.89 (PB3)
GNDS: C1.2, C2.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.1, C18.1, C19.2, C20.2, C21.1, C22.2, C23.2, C24.1, C25.2, C28.2, C29.2, C30.2, JOLED1.1, J_SWJ_DB1.3, R5.2, TPG1.1, TPG2.1, TPG3.1, TPG4.1, TPG5.1, TPG6.1, TPG7.1, TPG8.1, TPG9.1, TPG10.1, U1.4 (V-), U2.6 (VBAT), U2.10 (VSS), U2.19 (VSSA), U2.20 (VREF-), U2.27 (VSS), U2.49 (VSS), U2.74 (VSS), U2.99 (VSS), U3.2 (GND), U4.2 (GND), U_BTN1.2, U_BTN2.2, U_BTN3.2, U_BTN5.2; also elsewhere on the board
unnamed: C1.1, JP5.1, R3.1, U1.3 (+)
unnamed: C2.2, JP6.1, R4.1, U1.5 (+)
unnamed: C3.1, R2.1, R3.2
unnamed: C4.2, R1.1, R4.2
unnamed: C21.2, L1.1, TP18.1, U3.5 (VREF)
unnamed: C22.1, L2.1, TP19.1, U4.5 (VOUT)
unnamed: C26.1, R8.2, U1.2 (-)
unnamed: C27.1, R9.2, U1.6 (-)
unnamed: R5.1, U2.94 (PH3)

Notes on the sheet:
Micro Controller
Input Section
Output Section
GPIO_EXTI0 (PDWN)
GPIO_EXTI1 (PDWN)
GPIO_EXTI2 (PDWN)
GPIO_OUTPUT (PDWN)
EXTI (PUP)
Mounting connector “risers”. Two connectors per switch. Middle pins to be removed.
To be used with: Front-mounted keypad, non-shielded, non-backlit. Grayhill-96AB2-102-F http://www.grayhill.com/assets/1/7/Keypads_96.pdf
8-position connector with 1 position removed.
Voltage Regulator and Voltage Reference
TO BYPASS: 1) Remove U1 2) Solder JP5, JP6, R1 and R2 3) Populate R3, R4 with 100R and C1, C2 with 100nF for FC=15KHz
Passives footprint to be left empty if direct PCB connection is used.

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
Board: 2 copper layers, 243.8 x 95.2 mm, 95 parts (72 on the bottom side), 42 nets.

Other parts of the board:
R14: 220R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R15: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U_BTNRST1: Tactile_Switch_SPST-NO; 12x12x7_3mmTactilePushButtonMomentary

Their connections:
+3V3: R14.1, R15.1; also elsewhere on the board
GNDS: U_BTNRST1.2; also elsewhere on the board

## KiCad design HW/CurrentSinkModule/CurrentSinkModule/CurrentSinkModule.kicad_pcb

Parts:
D1, D2: D_Schottky; D_SOD-123
GND9: TestPoint; TestPoint_Pad_2.0x2.0mm; MouserNo 855-S2751-46R
JADC1, JADC2: SMA_RG402_Coax; SMA_Amphenol_901-144_Vertical; DigikeyNo A97594-ND
JDAC1, JDAC2: SMA_RG402_Coax; SMA_Amphenol_901-144_Vertical; DigikeyNo A97594-ND
JP1, JP2, JP3, JP4: Isolation; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JPWR1: Conn_01x03; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J_SUTNEG1: MolexMicroFit_01x02; Molex_Micro-Fit_3.0_43045-0212_2x01_P3.00mm_Vertical
J_SUTPOS1: MolexMicroFit_01x02; Molex_Micro-Fit_3.0_43045-0212_2x01_P3.00mm_Vertical
TP1, TP2: TestPoint; TestPoint_Pad_2.0x2.0mm; MouserNo 855-S2751-46R

Connections:
+12V: D1.1 (K), TP2.1; also elsewhere on the board
-12V: D2.2 (A), TP1.1; also elsewhere on the board
/CurrentSink/ADCSIG1: JADC1.1 (In); also elsewhere on the board
/CurrentSink/ADCSIG2: JADC2.1 (In); also elsewhere on the board
/CurrentSink/DACSIG1: JDAC1.1 (In); also elsewhere on the board
/CurrentSink/DACSIG2: JDAC2.1 (In); also elsewhere on the board
/CurrentSink/DUT_NEG: J_SUTNEG1.1; also elsewhere on the board
/CurrentSink/DUT_POS: J_SUTPOS1.1; also elsewhere on the board
GNDS: GND9.1, JP1.2, JP2.2, JP3.1, JP4.1, JPWR1.2, J_SUTNEG1.2, J_SUTPOS1.2; also elsewhere on the board
unnamed: D1.2 (A), JPWR1.1
unnamed: D2.1 (K), JPWR1.3
unnamed: JADC1.2 (Ext), JP3.2
unnamed: JADC2.2 (Ext), JP4.2
unnamed: JDAC1.2 (Ext), JP1.1
unnamed: JDAC2.2 (Ext), JP2.1

Notes on the sheet:
Ext. Power Cable

## Code that names these connections

File SW/STM32L496_DigitalCurrentSinkV3/STM32L496_DigitalCurrentSinkV3.ioc (part):

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Mcu.Name=STM32L496V(E-G)Tx
Mcu.Package=LQFP100
Mcu.UserName=STM32L496VETx
PA1.Signal=ADCx_IN6
PA13\ (JTMS/SWDIO).Mode=Trace_Asynchronous_SW
PA13\ (JTMS/SWDIO).Signal=SYS_JTMS-SWDIO
PA14\ (JTCK/SWCLK).Mode=Trace_Asynchronous_SW
PA14\ (JTCK/SWCLK).Signal=SYS_JTCK-SWCLK
PA2.Signal=ADCx_IN7
PA4.Signal=COMP_DAC11_group
PA5.Signal=COMP_DAC12_group
PB0.GPIOParameters=GPIO_PuPd,GPIO_Label
PB0.GPIO_Label=KP5_EXTI0
PB0.GPIO_PuPd=GPIO_PULLDOWN
PB0.Signal=GPXTI0
PB1.GPIOParameters=GPIO_PuPd,GPIO_Label
PB1.GPIO_Label=KP6_EXTI1
PB1.GPIO_PuPd=GPIO_PULLDOWN
PB1.Signal=GPXTI1
PB2.GPIOParameters=GPIO_PuPd,GPIO_Label
PB2.GPIO_Label=KP7_EXTI2
PB2.GPIO_PuPd=GPIO_PULLDOWN
PB2.Signal=GPXTI2
PB3\ (JTDO/TRACESWO).Mode=Trace_Asynchronous_SW
PB3\ (JTDO/TRACESWO).Signal=SYS_JTDO-SWO
PB6.GPIOParameters=GPIO_FM6,GPIO_Speed,GPIO_PuPdOD
PB6.GPIO_FM6=__NULL
PB6.GPIO_PuPdOD=GPIO_PULLUP
PB6.GPIO_Speed=GPIO_SPEED_FREQ_LOW
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.GPIOParameters=GPIO_Speed,GPIO_PuPdOD,GPIO_FM7
PB7.GPIO_FM7=__NULL
PB7.GPIO_PuPdOD=GPIO_PULLUP
PB7.GPIO_Speed=GPIO_SPEED_FREQ_LOW
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PC1.GPIOParameters=GPIO_Speed,PinState,GPIO_PuPd,GPIO_Label
PC1.GPIO_Label=OLED_RST
PC1.GPIO_PuPd=GPIO_PULLUP
PC1.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PC1.PinState=GPIO_PIN_SET
PC1.Signal=GPIO_Output
PD10.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultEXTI
PD10.GPIO_Label=Btn1_EXT10
PD10.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PD10.GPIO_PuPd=GPIO_PULLUP
PD10.Signal=GPXTI10
PD11.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultEXTI
PD11.GPIO_Label=Btn2_EXT11
PD11.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PD11.GPIO_PuPd=GPIO_PULLUP
PD11.Signal=GPXTI11
PD12.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultEXTI
PD12.GPIO_Label=Btn3_EXT12
PD12.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PD12.GPIO_PuPd=GPIO_PULLUP
PD12.Signal=GPXTI12
PD13.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultEXTI
PD13.GPIO_Label=Btn4_EXT13
PD13.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PD13.GPIO_PuPd=GPIO_PULLUP
PD13.Signal=GPXTI13
PE10.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label
PE10.GPIO_Label=KP4_GPOUT
PE10.GPIO_PuPd=GPIO_PULLUP
PE10.PinState=GPIO_PIN_SET
PE10.Signal=GPIO_Output
PE7.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label
PE7.GPIO_Label=KP1_GPOUT
PE7.GPIO_PuPd=GPIO_PULLUP
PE7.PinState=GPIO_PIN_SET
PE7.Signal=GPIO_Output
PE8.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label
PE8.GPIO_Label=KP2_GPOUT
PE8.GPIO_PuPd=GPIO_PULLUP
PE8.PinState=GPIO_PIN_SET
PE8.Signal=GPIO_Output
PE9.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label
PE9.GPIO_Label=KP3_GPOUT
PE9.GPIO_PuPd=GPIO_PULLUP
PE9.PinState=GPIO_PIN_SET
PE9.Signal=GPIO_Output
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=80000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2019-07-18 Updates
    - New simplified current sink design: see LTSpice model "MOSFET_CurrentSense_NoSignalInversion".
    Needs to be confirmed on breadboard!
2019-07-18 - New simplified current sink design: see LTSpice model "MOSFET_CurrentSense_NoSignalInversion". Needs to be confirmed on breadboard!
2019-07-19 Finished CurrentSinkRevC layout
2019-07-21 Added Interafec IBOMS
2019-08-03 Created STM32L476 project
2019-08-03 Tested SWO, I2C OLED and DAC (triangle outputs)
2019-08-03 debugged HW issue with EXTI buttons
    - Buttons required external pull-up resistors
2019-08-03 updated software
    - Added DAC helper functions, including mode select, voltage and frequency increase
    - Unexplained noise present on DAC channel 1. Suddenly appeared without explanation. Confirmed code and settings. Chip might need replacing.
2019-08-03 save update
2019-08-04 updated SW
    - Tested OLED with shorter molex kk254 connector
    - Added screen overlay w/ data
    - Added DAC functions to calculate DAC output voltage and timer freq
2019-08-05 updated hw
    - finished layout for power supply
2019-08-05 updated HW
    - ExternRegulatedConverter_12D_12S_5S layout optimised for etching
2019-08-05 updated SW
    - Enabled EXTI for keypad, only printf to SWD console
    - Added statemachine for display. Navigate to main/mode/value screens via top menu/tactile buttons
2019-08-06 updated sw
    - Added blinking
2019-08-12 current module hw update
    - Deleted opamp Bypass jumpers in schematic; they break opamp configurations
    - Added bypass instructions in schematic for each opamp.
2019-08-12 updated sw
    - Added keypad functions
2019-08-13 updated SW
    - Added preview for setting volts/hertz via keypad and nudge controls, previewed value is applied using "SET" menu button or cancelled using "EXIT" menu button
    - TODO add decimal point support for entered value
2019-08-13 updated SW
    - Added debug for new value settings (implemented timer15 to wait 1-3 cycles for DAC conversion to complete)
2019-08-13 updated SW
    - Added support for decimal points in "set value" screen
2019-08-14 updated SW
    - Refactored code with GNU coding standard
2019-08-15 updated SW
    - Tested HW with ADC enabled. Basic SWDIO debug data received (with unexpected 200mV offset)
2019-08-18 Tested RevC LTC3260 fixes
    - updated passive LTC3260 component values
2019-08-19 added notes to current sink module schematic
2019-08-19 Tested Contrl Module ADC input filter. Updated schematic for removing >1MHz noise.
2019-08-20 updated SW
    - Moved DisplayManager::DM_GetSelectedDac() function to DacUtilities::DU_getActiveDACChannel() function
    - Added DacUtilities::DU_setActiveDACChannel() function
2019-08-20 updated SW
    - Added DAC mode preview so user can choose mode without setting the registers. Registers are set at the end of then menu sequence when user confirms chosen parameters.
2019-08-20 updated SW
    - Added single and dual DAC voltage set functionality
2019-08-20 software update
    - Fixed some bugs in the UI code
2019-08-20 updated SW
    - Added single/dual reset and nudge adjust function
2019-08-21 migrated HW
    - Changed STM32L476 to STM32L496 (STM32L476 did not support ADC->DFSDM config)
    - Created new SW project "STM32L496_DigitalCurrentSinkV3"
    - Confirmed compilation success with all libs and firmware.
2019-08-22 Tested STM32L496VG upgrade, replaced symbol in schematic
2019-08-23 software update
    - Moved I2C HAL_Delay to after DAC init, minimizes any current surge on DUT
2019-08-24 Configured ADC->DFSDM HW filter
2019-08-24 Disabled DFSDM filter and rolled back to ADC DMA w/ oversampling
2019-08-25 updated SW
    - Added new "Amplitude Setting" menu screen for setting triangle amplitude of auto mode
    - Auto mode amplitude range can be set: DAC_TRIANGLEAMPLITUDE_7 --> DAC_TRIANGLEAMPLITUDE_4095
2019-08-25 updated sw
    - Added functions
    to adjust amp input to voltage DAC output. to amps output
2019-08-25 sw update
    Added functions to:
    - Convert amps user input to DAC voltage output
    - ADC voltage input to OLED display amps output
    - Added gain compensation for ADC input. Alt could be to increase INAMP gain resistor?
2019-08-26 updated sw
    - Added noise/random user amplitude selection function
    - Added 3x5 font.
2019-08-26 updated sw
    - Added seperate timer prescaler for slower freq when using RAND mode.
    - Fixed fonts and display issues
2019-08-26 updated sw
    - Fixed decimal point display issues. Decimal point is displayed when DP button is pressed as opposed to only after 1st decimal place is entered.
    - Fixed truncation issues when calculating volts (float) from bits.
2019-08-28 updated sw
    - fixed bug where CH2 auto mode amplitude could not be set. On startup.
2019-08-30 updated SW
    - Adjusted INAMP_GAIN_COMP
    - Added functions to
    - Limit input amps to 3A
    - Limit AUTO and RANDOM modes to 3A
    - Execute full reset (DU_FullReset)
    - AU_CalcCurrent will call DU_FullReset if current exceeds 3A
2019-08-31 updates
    - Replaced steel M3 busbar with lower resistance 9AWG copper conduit cable
    - Adjusted system constants to correct for above changes in resistance.
2019-09-10 added front panel design
2019-09-20 updated power supply and front panel
2019-09-21 added 24V PSU
2019-09-21 updated sw boot order
2019-09-22 updated currentsink schematic
2019-09-22 expanded display aperture on front panel
2019-09-23 RevA layout PSU
2019-09-23 updated RevA SMPS layout
2019-09-23 updated layout
2019-09-29 adjusted callibration in SW
2019-10-10 UPDATED 24VIN_PSU
    - Added 5V DC2DC input inductor (1mH)
    - Added 3mm THT LEDs for output rail status
2019-10-13 updated sw
    - Upgraded MOSFETS to IXFK50N85X/IXTK90P20P
    - Recalibrated firmware
2019-10-29 updated HW
    - Created 24VIN_ExternRegulatedConverter_12D_24S_5S
2019-11-17 updated HW
    - Added front panel NRST switch
    - Changed 0402 to 0805 input filter, added NC jumper

Notices in the files:
HW/ControlModule/ControlModule.kicad_pcb:
1719 © C.Sutton
HW/CurrentSinkModule/CurrentSinkModule/CurrentSinkModule.kicad_pcb:
C.Sutton © 2919
